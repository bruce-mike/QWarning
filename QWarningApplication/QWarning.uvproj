# Keil uVision project QWarning.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2366 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: QWarning +hex
  AfterMake: ..\srecord-1.64-win32\srec_cat.exe  ..\Bootloader\Obj\Bootloader.hex -Intel Objs\QWarning.hex -Intel -o   ..\ApplicationWithBootloader\MergedHexFile.hex -Intel
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=Objs\QWarning.bin Objs\QWarning.axf
  c flags: Optim=3 uC99=1 wLevel=2
  c misc: --asm
  c include: C:\Keil\ARM\INC\Phillips;..\SharedCode
  memory RVCT4: ROM 0x4000 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup
    ./: LPC2300.s
  group Source
    ./: adc.c assetTracker.c fram.c gpio.c irqs.c log.c Main.c misc.c PLL.c radar.c rateLimiter.c retarget.c serial.c sensor.c timer.c watchdog.c crc32.c
    ../SharedCode/: iap.c
  group Inc
    ./: adc.h assetTracker.h fram.h gpio.h irq2.h irqs.h log.h misc.h PLL.h radar.h rateLimiter.h serial.h sensor.h shareddefs.h sharedinterface.h timer.h watchdog.h
