# Keil uVision project Bootloader.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2366 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Bootloader +hex
  AfterMake: ..\srecord-1.64-win32\srec_cat.exe  Obj\Bootloader.hex -Intel ..\QWarningApplication\Objs\QWarning.hex -Intel -o ..\ApplicationWithBootloader\MergedHexFile.hex -Intel
  c flags: Optim=3
  c include: C:\Keil\ARM\INC\Phillips;..\SharedCode
  memory RVCT4: ROM 0x0 size 0x1c000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup
    ./: LPC2300.s
  group Code
    ./: main.c retarget.c irq.c PLL.c watchdog.c softwareVersion.h
    ../SharedLibrary/: sharedinterface.h
    ../SharedCode/: iap.c
